# Keil uVision project lab8.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab8
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\KEY;.\HARDWARE\TOUCH;.\HARDWARE\LED;.\HARDWARE\LCD;.\HARDWARE\RTC;.\USMART;.\HARDWARE\REMOTE;.\HARDWARE\ADC;.\HARDWARE\ITEMP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group HARDWARE
    ./HARDWARE/24CXX/: 24cxx.h 24cxx.c
    ./HARDWARE/IIC/: myiic.c myiic.h
    ./HARDWARE/KEY/: key.c key.h
    ./HARDWARE/LCD/: FONT.H lcd.h lcd.c
    ./HARDWARE/LED/: led.c led.h
    ./HARDWARE/TOUCH/: ctiic.c ctiic.h ft5206.c ft5206.h gt9147.c gt9147.h ott2001a.c ott2001a.h touch.c touch.h
    ./HARDWARE/RTC/: rtc.c rtc.h
    ./USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
    ./HARDWARE/ADC/: adc.c adc.h
    ./HARDWARE/ITEMP/: tsensor.c tsensor.h
    ./HARDWARE/REMOTE/: remote.c remote.h
  group SYSTEM
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/usart/: usart.c usart.h
  group USER
    ./: main.c
  group CORE
    ./CORE/: core_cm3.c core_cm3.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
